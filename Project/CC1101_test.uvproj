# Keil uVision project CC1101_test.uvproj, settings and files
target CC1101_test (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: CC1101_ctrl +hex
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX
  c include: ..\User;..\Libraries\FWlib\inc;..\Libraries\CMSIS\ST\STM32F4xx\Include;..\Libraries\STM32F4-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/FWlib/src/: misc.c stm32f4xx_exti.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_gpio.c stm32f4xx_spi.c stm32f4xx_usart.c stm32f4xx_tim.c
  group CMSIS
    ../Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../Libraries/CMSIS/ST/STM32F4xx/Include/: stm32f4xx.h system_stm32f4xx.h
  group STM32F-Discovery
    ../Libraries/STM32F4-Discovery/: stm32f4_discovery.c
  group USER
    ../User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
    ../User/usart/: bsp_debug_usart.c bsp_debug_usart.h
    ../User/tim/: bsp_basic_tim.c bsp_basic_tim.h
    ../User/cc1101/: cc1101.c cc1101.h cc1101_reg.h
    ../User/spi/: bsp_spi.c bsp_spi.h
    ../User/key/: bsp_key.c bsp_key.h
  group DOC
    ../Doc/: README.txt
